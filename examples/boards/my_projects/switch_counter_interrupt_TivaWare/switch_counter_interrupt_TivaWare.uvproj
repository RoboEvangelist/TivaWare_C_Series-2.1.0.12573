# Keil uVision project switch_counter_interrupt_TivaWare.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: switch_counter_interrupt_TivaWare
  c flags: Optim=1
  c define: rvmdk PART_TM4C1294NCPDT
  c misc: --c99
  c include: ..\..\..\..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S switch_counter_interrupt_TivaWare.c switch_counter_interrupt_TivaWare.h
    ../../../../driverlib/rvmdk/: driverlib.lib
