# Keil uVision project ADCT0ATrigger.uvproj, settings and files
target ADCT0ATrigger (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCT0ATrigger
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: startup.s ADCT0ATrigger.c ADCTestMain.c PLL.c
